# Keil uVision project STM32-LCD-TFT.uvprojx, settings and files
target STM32-FD-TFT (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_FD_USART +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\user;.\FWlib\inc;.\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: lcd_dis24.c main.c pic.c
  group StdPeriph_Driver
    ./FWlib/SRC/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group RVMDK
    ./startup/: startup_stm32f10x_hd.s
  group Doc
    ./: readme.txt
  group CMSIS
    ./CM3/: core_cm3.c system_stm32f10x.c
