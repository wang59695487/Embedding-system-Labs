# Keil uVision project STM32-FD-ADC.uvprojx, settings and files
target STM32-FD-ADC (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD-ADC +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group user
    ./user/: main.c
  group FWLIB
    ./FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group readme
    ./: readme.txt
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
