# Keil uVision project STM32-FD-TIM3-PWM.uvprojx, settings and files
target STM32-FD-TIM3-PWM (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD-TIM3-PWM +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\APP;..\BSP;..\FWLib\inc;..\Startup;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\uCGUIConfig;..\GUIinc;..\TFT;..\CM3;..\fatfs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group APP
    ./: Tim.c main.c stm32f10x_it.c
  group FWLib
    ../FWlib/SRC/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group Documentation
    ./: readme.txt
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
