# Keil uVision project STM32-FD-ucgui.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD-ucgui +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\APP;..\BSP;..\FWLib\inc;..\Startup;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\uCGUIConfig;..\uCGUI\emWinDemo;..\GUIinc;..\TFT;..\uCGUI\uCGUIDemo;..\CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: stm32f10x_startup.s
  group APP
    ./: app.c stm32f10x_it.c Fun.c
  group BSP
    ../BSP/: bsp.c
  group FWLib
    ../FWlib/SRC/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCGUILib
    ../uCGUILib/: uCGUI_DEMO.lib
  group Documentation
    ./: readme.txt
  group uCOS-II/GUI_X
    ../uCOS-IIGUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
  group TFT
    ./: fsmc_sram.c
    ../TFT/: lcd.c lcd_api.c lcd_ucgui.c lcdrv.c
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
  group font
    ../font/: SimSun_13.c
